# Keil uVision project lv_test.uvprojx, settings and files
target SWM320 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.9.7
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: lv_test +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\SWM320_Lib\SWM320_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\SWM320_Lib\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver;.\tft;..\USER;..\SWM320_Lib\SWM320_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\lv_swm320_5.1;..\..\飞天二号调好LITTLVEGL480X272;.\BSP_Driv;.\FATFS;..\SWM320_Lib\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver;..\lvgl\lv_misc;..\lvgl\lv_hal;..\..\8M8
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CSL\StdPD
    ../SWM320_Lib/SWM320_StdPeriph_Driver/CSL/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_can.c SWM320_crc.c SWM320_dma.c SWM320_exti.c SWM320_flash.c SWM320_gpio.c SWM320_i2c.c SWM320_lcd.c SWM320_norflash.c SWM320_port.c SWM320_pwm.c SWM320_rtc.c SWM320_sdio.c SWM320_sdram.c SWM320_spi.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c
  group CSL\CMSIS
    ../SWM320_Lib/SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../SWM320_Lib/SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
  group lvgl
    ../lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
    ../lvgl/lv_draw/: lv_draw.c lv_draw_rbasic.c lv_draw_vbasic.c
    ../lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_trigo.c lv_txt.c lv_ufs.c
    ../lvgl/lv_objx/: lv_bar.c lv_btn.c lv_btnm.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
    ../lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_font
    ../lvgl/lv_misc/lv_fonts/: lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group USER
    ./: main.c
  group tft
    ./tft/: tft.c
  group touchpad
    ./touchpad/: touchpad.c
  group demo
    ../lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
    ../lv_examples/lv_tutorial/1_hello_world/: lv_tutorial_hello_world.c
    ../lv_examples/lv_apps/sysmon/: sysmon.c
    ../lv_examples/lv_apps/terminal/: terminal.c
    ../lv_examples/lv_apps/benchmark/: benchmark.c benchmark_bg.c
    ../lv_examples/lv_tutorial/7_fonts/: arial_ascii_20.c arial_cyrillic_20.c arial_math_20.c lv_tutorial_fonts.c
    ../lv_examples/lv_tests/lv_test_objx/lv_test_slider/: lv_test_slider.c
  group bsp_driver
    ./BSP_Driv/: bsp_SysTick.c bsp_I2C_GT9XX.c bsp_GT9XX.c bsp_UART.c bsp_SPIFlash.c bsp_SDIO.c
  group FatFS
    ./FATFS/: diskio.c ff.c ffunicode.c
